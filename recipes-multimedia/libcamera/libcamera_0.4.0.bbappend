PACKAGECONFIG = "dng gst"

FILES:${PN} += "${libdir}/gstreamer-1.0/libgstlibcamera.so"
